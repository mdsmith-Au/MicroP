# Keil uVision project Lab1_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab1_Project
  c flags: Optim=4 oTime=1 wLevel=2
  c misc: --c99
  c include: .\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: fputc_debug.c main.c system_stm32f4xx.c startup_stm32f40xx.s assembly_testbench.s c_testbench.c factorization_testbench.c gcd.c lcm.c primefactorization.c c_fermat.c
    ./: fermat_fact.s
